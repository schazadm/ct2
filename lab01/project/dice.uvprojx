# Keil uVision project dice.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: CT_Board_HS14_M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.3
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: dice
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -Wno-padded
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6314
  group app
    ./app/: dice_counter.c main.c statistics.c lcd.c dice_counter.h lcd.h statistics.h
software components: Device:Startup 4.0.3, HAL:CT Board:7 segment 4.0.0, HAL:FMC 3.0.1, HAL:GPIO 4.0.1, HAL:PWR 2.2.0, HAL:RCC 4.0.1
